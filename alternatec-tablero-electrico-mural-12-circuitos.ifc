Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: alternatec-tablero-electrico-mural-12-circuitos.ifc
Time: 2026-08-07T12:00:00
Author: Alternatec BIM
Organization: ALTERNATEC Engineering
Written by: Alternatec OpenBIM Generator 1.0
Made in: ALTERNATEC Engineering

# IfcBuildingStorey, Reference Level
In: Generic Building
Elevation: 0 mm

# IfcElectricDistributionBoard: Wall-mounted electrical distribution board, Tablero electrico mural - 12 circuitos
In: Reference Level
Description: Objeto BIM generico para coordinacion y anteproyecto. Gabinete mural de baja tension.; PredefinedType: DISTRIBUTIONBOARD; Material: Powder-coated steel
Pset_AlternatecElectrical - Manufacturer: Generic / Alternatec Library; ModelReference: ALT-EDB-12C; ClassificationCode: Pr_60_70_22_24; NominalVoltage: 208; RatedCurrent: 125; NumberOfCircuits: 12; IngressProtection: IP54; MountingType: Wall mounted; Width: 600 mm; Height: 800 mm; Depth: 180 mm; ModelPurpose: Concept design and multidisciplinary coordination
